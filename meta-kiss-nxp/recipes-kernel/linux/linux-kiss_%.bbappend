FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:freiheit93 = " file://0002-arm64-dts-imx93-11x11-frdm-disable-lpuart5-hw-flow-.patch"
